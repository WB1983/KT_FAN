# Keil uVision project KT_FAN.uvprojx, settings and files
target KT_FAN (6100001::V6.10.1::.\ARMCLANG)
  device: MM32SPIN0280D6P MindMotion
  pack: MindMotion.MM32SPIN0280_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KT_FAN +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Device\CMSIS\KEIL_CORE;..\ClassBTest\Library\inc;..\Device\CMSIS\KEIL_Core;..\Device\MM32SPIN0280\HAL_Lib\Inc;..\Device\MM32SPIN0280\Include;..\Device\MM32SPIN0280\Source;..\SYSTEM\Inc;..\USER\Inc;..\Application\inc;..\BSP_DRV\inc;..\Common\inc;..\FS\inc;..\MM_MCLIB\inc;..\MOTOR_CONTROL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\KT_FAN.sct
  link misc: --diag_suppress=L6329
  group USER
    ../USER/Src/: delay.c main.c sys.c board.c mm32_it.c user_function.c
  group Application
    ../Application/: Modbus.c ModbusCRC.c TimeSlice.c SpeedControl.c ErrorHandle.c AppModbus2Stm.c Modbus_2.c
  group MotorControl
    ../MOTOR_CONTROL/: FOC_PMSM.c Ramp.c StateMachine.c WindDetection.c
  group FS
    ../FS/: fsHandle.c fsMCU.c fsPhaseLoss.c fsRotorLock.c SpeedMonitor.c fsClock.c fsCommon.c fsMonitor.c fsTemperature.c
  group Common
    ../Common/: Common.c Current.c Voltage.c Math.c Filter.c Transfer.c SIMEEP.c ErrorReact.c StateMachineCom.c
  group BSP_DRV
    ../BSP_DRV/: drv_adc.c drv_comp.c drv_div.c drv_iic.c drv_iwdg.c drv_led.c drv_opamp.c drv_pwm.c drv_sci.c drv_sqrt.c drv_Counter.c drv_Output.c drv_Capture.c drv_dma.c drv_eep.c drv_sci_2.c
  group HAL
    ../Device/MM32SPIN0280/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group Startup
    ../Device/MM32SPIN0280/Source/KEIL_StartAsm/: startup_mm32spin0280_keil.s
    ../Device/MM32SPIN0280/Source/: system_mm32spin0280.c
  group SYSTEM
    ../SYSTEM/Src/: uart_classb.c
  group MM_MCLIB
    ../MM_MCLIB/: MCFLIB.lib MLIB.lib
    ../MM_MCLIB/inc/: mcflib.h mlib.h
  group Lib_ClassB
    ../ClassBTest/Library/src/: IEC60730_B_aux.c IEC60730_B_clocktest.c IEC60730_B_runtimetest.c IEC60730_B_startup.c
  group SRC_ClassB
    ../ClassBTest/Library/: IEC60730B_M0_COM_KEIL_v1_0.lib
  group README
    ../: README.TXT
