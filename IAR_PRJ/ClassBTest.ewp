# IAR project ClassBTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN0280D6P MindMotion MM32SPIN0280D6P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR
  ICCARM.CCIncludePath2: ..\Device\CMSIS\IAR_CORE; ..\Device\MM32SPIN0280\HAL_Lib\Inc; ..\Device\MM32SPIN0280\Include; ..\ClassBTest\Library\inc; ..\USER\Inc; ..\SYSTEM\Inc; ..\Device\MM32SPIN0280\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ClassBTest.hex
  postbuild: crc_gen_keil.bat
  ILINK.IlinkOutputFile: ClassBTest.out
  ILINK.IlinkIcfFile: MM32SPIN0280_CLASSB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ClassBSelefTestLib
    ../ClassBTest/Library/src/: IEC60730_B_aux.c IEC60730_B_clocktest.c IEC60730_B_runtimetest.c IEC60730_B_startup.c
  group ClassBSelfTestIAR
    ../ClassBTest/Library/: IEC60730B_M0_COM_IAR_v1_0.a
  group HALlib
    ../Device/MM32SPIN0280/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../Device/MM32SPIN0280/Source/IAR_StartAsm/: startup_mm32spin0280_iar.s
    ../Device/MM32SPIN0280/Source/: system_mm32spin0280.c
  group SYSTEM
    ../SYSTEM/Src/: uart_classb.c
  group USER
    ../USER/Src/: delay.c main.c sys.c
