# IAR project Backup of ClassBTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PF MindMotion MM32SPIN27PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR
  ICCARM.CCIncludePath2: ..\Device\CMSIS\IAR_CORE; ..\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc; ..\Device\MM32SPIN2xx_p_LIB\Include; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\HARDWARE\LED; ..\ClassBTest\Library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ClassBTest.hex
  ILINK.IlinkOutputFile: ClassBTest.out
  ILINK.IlinkIcfFile: ClassBTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ClassBSelefTestLib
    ../ClassBTest/Library/src/: mm32_STLclockrun.c mm32_STLclockstart.c mm32_STLcrc32Run.c mm32_STLmain.c mm32_STLstartup.c mm32_STLtranspRam.c
  group ClassBSelfTestIAR
    ../ClassBTest/: mm32_STLcpurunIAR.s mm32_STLcpustartIAR.s mm32_STLRamMcMxIAR.s
  group HALlib
    ../Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group STARTUP
    ../Device/MM32SPIN2xx_p_LIB/Source/IAR_StartAsm/: startup_MM32SPIN2xx_p.s
    ../Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: main.c
